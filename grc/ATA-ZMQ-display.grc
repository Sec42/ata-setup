options:
  parameters:
    author: paul
    generate_options: qt_gui
    id: default_is_fine
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: chans
  id: variable
  parameters:
    value: '4096'
  states: {}
- name: blocks_deinterleave_0
  id: blocks_deinterleave
  parameters:
    type: float
    vlen: chans
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '40'
    type: float
    vlen: chans
  states: {}
- name: blocks_repeat_0_0
  id: blocks_repeat
  parameters:
    interp: '40'
    type: float
    vlen: chans
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    grid: 'True'
    name: Test FFT
    nconnections: '2'
    vlen: chans
    x_axis_label: '"Frequency (MHz)"'
    x_start: 1622-samp_rate/2/1e6
    x_step: samp_rate/chans/1e6
    x_units: '"MHz"'
    ymax: 5e10
    ymin: '0'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: sampling rate [Hz]
    short_id: b
    type: eng_float
    value: 12.5e6
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://10.1.50.11:50001
    timeout: '100'
    type: float
    vlen: chans
  states: {}

connections:
- [blocks_deinterleave_0, '0', blocks_repeat_0, '0']
- [blocks_deinterleave_0, '1', blocks_repeat_0_0, '0']
- [blocks_repeat_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_repeat_0_0, '0', qtgui_vector_sink_f_0, '1']
- [zeromq_sub_source_0, '0', blocks_deinterleave_0, '0']

metadata:
  file_format: 1
