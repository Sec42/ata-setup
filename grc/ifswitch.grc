options:
  parameters:
    generate_options: no_gui
    id: ifswitch
    output_language: python
    title: ifswitch
  states: {}

blocks:
- name: ata_control_0
  id: ata_control
  parameters:
    mode: online
    username: gnuradio
  states: {}
- name: ata_ifswitch_0
  id: ata_ifswitch
  parameters:
    ant1: none
    ant2: 1h
    ant3: none
  states: {}
- name: ata_trackscan_0
  id: ata_trackscan
  parameters:
    ant_list: 1h
    az: '180.0'
    cfreq: '1622.0'
    coord_type: azel
    dec: '67.0'
    el: '25'
    ra: '14.0'
    src: casa
  states: {}

connections:
- [ata_trackscan_0, command, ata_control_0, command]

metadata:
  file_format: 1
