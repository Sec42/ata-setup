options:
  parameters:
    generate_options: no_gui
    id: usrp_2chrx_save
    output_language: python
    run_options: run
  states: {}

blocks:
- name: chans
  id: variable
  parameters:
    value: '4096'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: chans
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: chans
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: test.cfile
    type: complex
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: '1000'
    type: float
    vlen: chans
  states: {}
- name: blocks_integrate_xx_0_0
  id: blocks_integrate_xx
  parameters:
    decim: '1000'
    type: float
    vlen: chans
  states: {}
- name: blocks_interleave_0
  id: blocks_interleave
  parameters:
    type: float
    vlen: chans
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: chans
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: chans
    type: complex
  states: {}
- name: fc
  id: parameter
  parameters:
    label: carrier frequency
    short_id: c
    type: eng_float
    value: 629e6
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: chans
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(chans)
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: chans
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(chans)
  states: {}
- name: gaindB
  id: parameter
  parameters:
    label: rx gain in decibels
    short_id: g
    type: eng_float
    value: '23'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: sampling rate [Hz]
    short_id: b
    type: eng_float
    value: 12.5e6
  states: {}
- name: uhd_usrp_source
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    ant1: TX/RX
    center_freq0: fc
    center_freq1: fc
    clock_rate: '0.0'
    clock_source0: external
    dc_offs_enb0: 'False'
    dc_offs_enb1: 'False'
    dev_addr: '"addr=10.11.2.61"'
    dev_args: '"master_clock_rate=250e6"'
    gain0: gaindB
    gain1: gaindB
    iq_imbal_enb0: 'False'
    iq_imbal_enb1: 'False'
    nchan: '2'
    norm_gain0: 'False'
    norm_gain1: 'False'
    otw: sc16
    samp_rate: samp_rate
    sd_spec0: A:0 B:0
    sync: sync
    time_source0: external
    type: fc32
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://*:50001
    timeout: '100'
    type: float
    vlen: chans
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_integrate_xx_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', blocks_integrate_xx_0_0, '0']
- [blocks_integrate_xx_0, '0', blocks_interleave_0, '0']
- [blocks_integrate_xx_0_0, '0', blocks_interleave_0, '1']
- [blocks_interleave_0, '0', zeromq_pub_sink_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0_0, '0']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [fft_vxx_0_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [uhd_usrp_source, '0', blocks_file_sink_0, '0']
- [uhd_usrp_source, '0', blocks_stream_to_vector_0_0, '0']
- [uhd_usrp_source, '1', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
